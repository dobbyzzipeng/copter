# Keil uVision project AIRMOUSE.uvprojx, settings and files
target TARGET (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.4
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: AIRMOUSE +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\APP;..\CONTROL;..\CORE;..\FLIW\inc;..\HARWAER\BSP;..\HARWAER\IIC;..\HARWAER\MPU6050;..\HARWAER\PWM;..\HARWAER\SPI_NRF24L01;..\HARWAER\TIMER;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\Math\inc;..\USER;..\HARWAER\LED;..\HARWAER\HMC5883L;..\HARWAER\STMFLASH
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: globalvariable.c main.c stm32f10x_it.c system_stm32f10x.c
  group APP
    ../CONTROL/: IMU.c ins.c Data_Tramsfer.c detectdog.c ramp.c pid_regulator.c
  group HARDWARE
    ../HARWAER/BSP/: bsp.c
    ../HARWAER/TIMER/: timer.c
    ../HARWAER/MPU6050/: MPU6050.c
    ../HARWAER/IIC/: myiic.c
    ../HARWAER/LED/: led.c
    ../HARWAER/STMFLASH/: stmflash.c
  group fastmath
    ../Math/src/: FastMath.c
  group FWLIB
    ../FLIW/src/: misc.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_flash.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s core_cm3.h
