# Keil uVision project 9AXISProject.uvprojx, settings and files
target 9AXISP (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.4
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 9AXISProject +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\STM32F10x_FWLib\inc;..\HARDWARE\IIC;..\HARDWARE\LED;..\HARDWARE\mpu9250;..\HARDWARE\SPI;..\CORE;..\AHRS;..\HARDWARE\TIMER;..\INS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group INS
    ../INS/: ins.c
  group AHRS
    ../AHRS/: ahrs.c
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/mpu9250/: mpu92xx.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/TIMER/: timer.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_spi.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c
